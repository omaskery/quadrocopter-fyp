# Keil uVision project test.uvproj, settings and files
target QuadrocopterFirmware (ARM-ADS)
  device: LM3S1968 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: test
  AfterMake: makebin.bat
  c flags: Optim=1 wLevel=2
  c include: C:\StellarisWare\boards\ek-lm3s1968;C:\StellarisWare
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: includes.h Startup.s main.c globals.h
  group Library
    C:/StellarisWare/driverlib/rvmdk-cm3/: driverlib-cm3.lib
  group Drivers
    C:/StellarisWare/driverlib/: ssi.c pwm.c fpu.c i2c.c
    C:/StellarisWare/boards/ek-lm3s1968/drivers/: rit128x96x4.c
  group Peripherals
    ./: usart.h usart.c mypwm.c mypwm.h iic.c iic.h timer.h timer.c
  group Utilities
    ./: queue.h queue.c init.h init.c
  group Hardware
    ./: motor.c motor.h sensor.c sensor.h
  group Logic
    ./: pid.c pid.h system.h system.c behaviour.h behaviour.c motion.c motion.h
